PACKAGECONFIG:append = " firstboot"
