PACKAGECONFIG:append = " ffplay vaapi"
PACKAGECONFIG[ffplay] = "--enable-ffplay,--disable-ffplay"
