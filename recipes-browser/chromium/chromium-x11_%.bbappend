PACKAGECONFIG = "proprietary-codecs use-vaapi"
